Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T15:39:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 15:39:57 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\360bbc6d-93b4-4e5a-b7d0-252b6a7dcd5c\ifc * Database version: 5507 * Database creation date: Mon Oct 24 15:39:56 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 15:39:56 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 15:39:56 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: Busch-balance SI_2CKA001725A1558_ver_2, E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN:Busch-balance SI_2CKA001725A1558_ver_2:3005566
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 15 mm; Gang Height: 56 mm; Gang Width: 56 mm; Height: 152 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 2 mm; Width: 81 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Alpine white; Material: Color RAL 9010; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Cover frame, alpine white, Cover frame Busch-Balance SI; Article Type: 2-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Cover frame, alpine white, Cover frame Busch-Balance SI; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395191514; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A1558; Manufacturer Type: 1722-914; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001725A1558,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2CKA001725A1558_ver_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2CKA001725A1558_ver_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_2CKA001725A1558_ver_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0227927 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000580757 m3
Electrical - Circuiting - Electrical Data: Power - Balanced1 230 V/1-200 VA-Power - Balanced2 230 V/1-200 VA
Electrical - Loads - Load Classification: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Annotation Offset Position: 7 mm; Family: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN: Busch-balance SI_2CKA001725A1558_ver_2; Family and Type: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN: Busch-balance SI_2CKA001725A1558_ver_2; Gang 3: 71 mm; Gang Reference Line: 127 mm; Interior Width: 28 mm; Number of Representation Line: 2; Type: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN: Busch-balance SI_2CKA001725A1558_ver_2; Type Id: E_Frame Vertical_Double Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-EN: Busch-balance SI_2CKA001725A1558_ver_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Busch-balance SI_with Earth 1F_2CKA002011A6238 (2)
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 55 mm; Rounding Radius: 1 mm; Width: 55 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpine white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: SCHUKO socket outlet without claw, alpine white, Socket outlets; Article Type: Socket outlet with PE recessed 1-fold; Base Family Version: 20221003; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: SCHUKO socket outlet without claw, alpine white, Socket outlets; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395191637; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002011A6238; Manufacturer Type: 20 EUCR-914; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA002011A6238,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Socket outlet with PE recessed 1-fold; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_with Earth 1F_2CKA002011A6238; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_with Earth 1F_2CKA002011A6238
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_with Earth 1F_2CKA002011A6238
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 19; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00641861 m2; Volume: 0.0000283672 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; VERSION: 220800
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN: Busch-balance SI_with Earth 1F_2CKA002011A6238; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN: Busch-balance SI_with Earth 1F_2CKA002011A6238; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN: Busch-balance SI_with Earth 1F_2CKA002011A6238; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN: Busch-balance SI_with Earth 1F_2CKA002011A6238
Phasing - Phase Created: 4. Plan over 10 years
Name (E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-EN:Busch-balance SI_with Earth 1F_2CKA002011A6238:...) | Mark
3005570 | 6
3005571 | 7
